# Keil uVision project Amonia.uvproj, settings and files
target Amonia (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Amonia +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Sources
    ./: main.c adc.c dac.c lcd.c misc.c tgs2444.c uart.c wdt.c rs485.c
  group Headers
    ./: adc.h dac.h lcd.h misc.h tgs2444.h uart.h wdt.h type.h rs485.h
